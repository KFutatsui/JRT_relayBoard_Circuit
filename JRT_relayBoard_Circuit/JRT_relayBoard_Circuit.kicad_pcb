# Repository KFutatsui/JRT_relayBoard_Circuit

## KiCad design JRT_relayBoard_Circuit/JRT_relayBoard_Circuit.kicad_pcb

Parts:
J1: Conn_ESP32_Left; PinSocket_1x15_P2.54mm_Vertical
J2: Conn_ESP32_Right; PinSocket_1x15_P2.54mm_Vertical
J3: eCON_D1-4; CONN_37212-62M3-003PL_3MM
J4: eCON_D5-8; CONN_37212-62M3-003PL_3MM
J5: eCON_D9-12; CONN_37212-62M3-003PL_3MM
J6: eCON_D13-15; CONN_37212-62M3-003PL_3MM
J7: eCON_A1-4; CONN_37212-62M3-003PL_3MM
J8: eCON_A5_UART_Vin_Vout; CONN_37212-62M3-003PL_3MM
J9: PowerSwitch; PinSocket_1x03_P2.54mm_Vertical

Connections:
+3.3V: J1.1, J7.2, J7.5, J7.8, J7.11, J8.2, J8.10
+9V: J8.7, J9.2
+9VA: J2.1, J9.3
A1: J2.10, J7.1
A2: J2.11, J7.4
A3: J2.12, J7.7
A4: J2.13, J7.10
A5: J2.14, J8.1
D1: J1.3, J3.1
D2: J1.5, J3.4
D3: J1.8, J3.7
D4: J1.9, J3.10
D5: J1.10, J4.1
D6: J1.11, J4.4
D7: J1.14, J4.7
D8: J1.15, J4.10
D9: J2.3, J5.1
D10: J2.4, J5.4
D11: J2.5, J5.7
D12: J2.6, J5.10
D13: J2.7, J6.1
D14: J2.8, J6.4
D15: J2.9, J6.7
GND: J2.2, J3.3, J3.6, J3.9, J3.12, J4.3, J4.6, J4.9, J4.12, J5.3, J5.6, J5.9, J5.12, J6.3, J6.6, J6.9, J6.12, J7.3, J7.6, J7.9, J7.12, J8.3, J8.9, J8.12
GND1: J1.2, J8.6
UART-RX: J1.6, J8.4
UART-TX: J1.7, J8.5

Notes on the sheet:
電源スイッチ
Analog入力端子 UART入出力端子 マイコン用電源入力端子 送信モジュール用電源出力端子
Digital入力端子
ESP32関係の配線 (ELEGOO ESP-32 開発ボード)

Board: 2 copper layers, 100.2 x 63.6 mm, 9 parts (0 on the bottom side), 27 nets.

## Commit log

2026-01-17 回路図を実装
2026-01-17 コネクタの配置をした
2026-01-17 配線を行った
2026-01-17 pcbデータ上に基板寸法を記録
2026-01-17 基板上のシルクを追加
2026-01-17 バックアップ系のファイルは上げないように変更
2026-01-17 GNDベタになるように修正
2026-01-18 CAD図のプロパティ情報を追加
2026-01-19 電源スイッチ取付用穴を追加
